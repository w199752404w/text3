# Keil uVision project BMS_LZH30.uvprojx, settings and files
target BMS_LZH30 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BMS_LZH30 +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ..\project\Objects\BMS_LZH30.bin ..\project\Objects\BMS_lZH30.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F10X_HD, __FPU_PRESENT
  c include: ..\CMSIS;..\Library\Include;..\User;..\bsp;..\app;..\protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: system_gd32f10x.c
  group Startup
    ../Startup/: startup_gd32f10x_hd.s
  group Library
    ../Library/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group User
    ../User/: main.c gd32f10x_it.c systick.c
  group bsp
    ../bsp/: bsp_gpio.c bsp_usart.c bsp.c bsp_tim.c bsp_can.c bsp_exti.c bsp_adc.c bsp_sh367309.c bsp_i2c.c bsp_wdg.c bsp_rtc.c bsp_gd25q32.c
  group app
    ../app/: verify.c config.c history.c local.c parallel.c
  group protocol
    ../protocol/: protocol.c eco.c ptc_eco.c
